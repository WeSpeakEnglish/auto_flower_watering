# IAR project STM32G031F.ewp, settings and files
configuration STM32G031F (ARM, debug)
  General.OGChipSelectEditMenu: STM32G031F6 ST STM32G031F6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; STM32G031xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32G031F.hex
  ILINK.IlinkOutputFile: STM32G031F.out
  ILINK.IlinkIcfFile: stm32g031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../Core/Src/: nortos.c main.c gpio.c adc.c tim.c stm32g0xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_pwr.c stm32g0xx_ll_tim.c
